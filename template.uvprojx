# Keil uVision project template.uvprojx, settings and files
target OVEN_PROJECT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\fileTV;.\src;.\fileTV\Timer;.\fileTV\Oven_Timer;.\fileTV\GPIO;.\fileTV\TFT_LCD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c main.c utils.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
  group startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_dma.c
  group fileTV
    ./fileTV/Oven_Timer/: Oven_Timer.c
    ./fileTV/GPIO/: GPIO.c
    ./fileTV/TFT_LCD/: TFT_LCD.c
